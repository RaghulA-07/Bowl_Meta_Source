#
# Copyright (C) 2017-2020 eForce, Co, Ltd.
#

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


SRC_URI += " \
    file://0001-machine-chipname-fix.patch \
" 
