CORE_IMAGE_EXTRA_INSTALL += "ecam-ar0234 copytofilesystem"

